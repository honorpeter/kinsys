IMAGE_INSTALL_append = " configs"
